# IAR project TSC_KeyLinearRotate.ewp, settings and files
configuration APM32F051 (ARM, debug)
  General.OGChipSelectEditMenu: APM32F051R8 Geehy APM32F051R8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_APM32F051_EVAL; APM32F051
  ICCARM.CCIncludePath2: ..\..\Include; ..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include; ..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\Include; ..\..\..\..\..\Libraries\TSC_Device_Lib\inc; ..\..\..\..\..\Boards; ..\..\..\..\..\Boards\Board_APM32F051_EVAL\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../Source/: apm32f0xx_int.c main.c tsc_user.c
  group Board
    ../../../../../Boards/: board.c
    ../../../../../Boards/Board_APM32F051_EVAL/src/: bsp_delay.c bsp_lcd.c
  group CMSIS
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/iar/: startup_apm32f051.s
    ../../Source/: system_apm32f0xx.c
  group StdPeriphLib
    ../../../../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group TouchDriver
    ../../../../../Libraries/TSC_Device_Lib/src/: tsc.c tsc_acq.c tsc_dxs.c tsc_ecs.c tsc_filter.c tsc_linrot.c tsc_object.c tsc_time.c tsc_touchkey.c
