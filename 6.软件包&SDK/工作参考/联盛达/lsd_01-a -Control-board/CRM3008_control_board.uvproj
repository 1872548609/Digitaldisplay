# Keil uVision project CRM3008_control_board.uvproj, settings and files
target Target 1 (MCS-51)
  device: OB38R16T1 On-Bright
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0-0x01FF) CLOCK(16000000)
  output: CRM3008_control_board
  c flags: Optimize=9
  c include: .\inc;.\USER
  group USER
    ./: STARTUP_OB38R08A1.A51
    ./USER/: main.c
  group SCR
    ./scr/: Gpio.c Logic.c Timer.c uart.c Key.c Display.c PWM.c Sensor.c EEPROM.c LVI_LVR.c
