# Keil uVision project CRM3008_control_board.uvproj, settings and files
target Target 1 (MCS-51)
  device: OB38R08A1 On-Bright
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) XRAM(0-0xFF) CLOCK(16000000)
  output: CRM3008_control_board
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc;.\USER
  group USER
    ./: STARTUP_OB38R08A1.A51
    ./USER/: main.c
  group SCR
    ./scr/: Gpio.c Logic.c Timer.c uart.c ADC.c Flow.c Sensor.c
