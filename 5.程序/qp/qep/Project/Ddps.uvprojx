# Keil uVision project Ddps.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: APM32F051K8 Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Ddps +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: BOARD_APM32F051_EVAL,APM32F051 __KEIL__  __IAR_SYSTEMS_ICC__
  c misc: --diag_suppress=188
  c include: ..\CMSIS;..\FWLib\inc;..\User\Main;..\User\Hardware;..\Boards\Board_APM32F051_EVAL\inc;..\Boards;..\User\Hardware\USER_DRIVER;..\User\Hardware\USER_HAL;..\User\Osal\include;..\User\Osal\hal\include;..\User\Osal\hal\target\CC2530EB;..\User\Osal\hal\TI2530DB;..\User\QEP\include;..\User\QEP\ports;..\User\QEP\qep
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../CMSIS/arm/: startup_apm32f051.s
    ../CMSIS/: system_apm32f0xx.c
  group FWlib
    ../FWLib/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_gpio.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group Boards
    ../Boards/: board.c
    ../Boards/Board_APM32F051_EVAL/src/: bsp_delay.c bsp_i2c_ee.c bsp_key.c bsp_lcd.c
  group Main
    ../User/Main/: apm32f0xx_int.c main.c mainfunction.c
  group USER_HAL
    ../User/Hardware/USER_HAL/: User_LED_HAL.c User_TMR_HAL.c User_KEY_HAL.c User_ADC_HAL.c User_Disp_HAL.c User_Disp_Font.h User_PWM_HAL.c User_Flash_HAL.c User_OUT_HAL.c User_Usart_HAL.c User_WDT_HAL.c
  group USER_DRIVER
    ../User/Hardware/USER_DRIVER/: User_LED_DIV.c User_KEY_DIV.c User_PWM_DIV.c User_Task_DIV.c User_Disp_Div.c User_ReadValue_DIV.c User_Usart_DIV.c User_Flash_DIV.c
  group QEP\qep
    ../User/QEP/qep/: qep.c qfsm_dis.c qfsm_ini.c qhsm_dis.c qhsm_in.c qhsm_ini.c qhsm_top.c
software components: CMSIS:CORE 5.0.1
