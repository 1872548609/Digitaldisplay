# Keil uVision project TSC_KeyLinearRotate.uvprojx, settings and files
target APM32F051 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F051R8 Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.7
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: TSC_KeyLinearRotate
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F051_EVAL,APM32F051
  c include: ..\..\..\..\..\Libraries\APM32F0xx_StdPeriphDriver\inc;..\..\..\..\..\Libraries\CMSIS\Include;..\..\..\..\..\Libraries\Device\Geehy\APM32F0xx\Include;..\..\..\..\..\Boards;..\..\Include;..\..\..\..\..\Libraries\TSC_Device_Lib\inc;..\..\..\..\..\Boards\Board_APM32F051_EVAL\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../../Source/: system_apm32f0xx.c
    ../../../../../Libraries/Device/Geehy/APM32F0xx/Source/arm/: startup_apm32f072.s
  group StdPeriphDriver
    ../../../../../Libraries/APM32F0xx_StdPeriphDriver/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group Board
    ../../../../../Boards/Board_APM32F051_EVAL/src/: bsp_delay.c bsp_lcd.c
    ../../../../../Boards/: board.c
  group TouchDriver
    ../../../../../Libraries/TSC_Device_Lib/src/: tsc.c tsc_acq.c tsc_dxs.c tsc_ecs.c tsc_filter.c tsc_linrot.c tsc_object.c tsc_time.c tsc_touchkey.c
    ../../Include/: tsc_config.h
  group Application
    ../../Source/: main.c apm32f0xx_int.c tsc_user.c
