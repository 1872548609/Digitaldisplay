# Keil uVision project optical_fiber.uvprojx, settings and files
target GPIO_Toggle (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CIU32L051R8Tx HED
  pack: HED.CIU32L0xx_DFP.1.2.6
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: optical_fiber +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CIU32L051 __KEIL__
  c include: ..\code\app;..\code\main;..\code\components\osal\common;..\code\components\osal\include;..\code\components\osal\mcu\ciu32l051;..\code\components\driver\lib\ciu32l051\Include;..\code\components\driver\usr\ciu32l051;..\code\components\bsp\ciu32l051;..\code\components\hal\common;..\code\components\hal\include;..\code\components\hal\target\ciu32l051;..\code\components\hal\target\ciu32l051\CMSIS;..\code\components\hal\target\ciu32l051\CMSIS\Device;..\code\components\hal\target\ciu32l051\CMSIS\Device\Startup\arm;..\code\components\hal\target\ciu32l051\CMSIS\core
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group app
    ../code/app/: iot_app_common_data.c iot_app_common_data.h iot_app_display.c iot_app_display.h iot_app_menu_item.c iot_app_menu_item.h iot_app_optical.c iot_app_optical.h iot_app_osal.c
  group main
    ../code/main/: main.c
    ../code/main/ciu32f051/: ciu32f051_int.c
  group osal
    ../code/components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c OSAL_Nv.c
    ../code/components/osal/include/: OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_PwrMgr.h OSAL_Timers.h ZComDef.h comdef.h
  group driver/lib
    ../code/components/driver/lib/ciu32l051/Source/: ciu32l051_std.c ciu32l051_std_adc.c ciu32l051_std_aes.c ciu32l051_std_comp.c ciu32l051_std_crc.c ciu32l051_std_dma.c ciu32l051_std_exti.c ciu32l051_std_flash.c ciu32l051_std_gpio.c ciu32l051_std_i2c.c ciu32l051_std_lcd.c ciu32l051_std_lptim.c ciu32l051_std_lpuart.c ciu32l051_std_pmu.c ciu32l051_std_rcc.c ciu32l051_std_rtc.c ciu32l051_std_spi.c ciu32l051_std_tamp.c ciu32l051_std_tim.c ciu32l051_std_trng.c ciu32l051_std_usart.c
  group driver/usr
    ../code/components/driver/usr/ciu32l051/: iot_driver_clock.h iot_driver_clock.c iot_driver_gpio.c iot_driver_gpio.h
  group hal/common
    ../code/components/hal/common/: hal_assert.c hal_drivers.c hal_key.c hal_led.c hal_nixietube.c
  group hal/include
    ../code/components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_key_adjust.h hal_lcd.h hal_led.h hal_nixietube_display.h hal_sleep.h hal_timer.h hal_uart.h
  group hal/target/ciu32l051
    ../code/components/hal/target/ciu32l051/: hal_types.h hal_mcu.h hal_board_cfg.h hal_flash.c
  group hal/target/ciu32l051/cmsis
    ../code/components/hal/target/ciu32l051/CMSIS/Device/Startup/arm/: startup_ciu32l051.s
    ../code/components/hal/target/ciu32l051/CMSIS/Device/: system_ciu32l051.c
