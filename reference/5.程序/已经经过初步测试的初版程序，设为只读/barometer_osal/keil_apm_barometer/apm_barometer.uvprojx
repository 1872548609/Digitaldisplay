# Keil uVision project apm_barometer.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32F051K8 Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: optical-fiber +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F051_EVAL,APM32F051 __KEIL__ ASSERT_WHILE
  c include: ..\code\main;..\code\app;..\code\app\barometer;..\code\components\osal\common;..\code\components\osal\include;..\code\components\osal\mcu\apm32f0xx;..\code\components\driver\lib\apm32f0xx\inc;..\code\components\driver\usr\apm32f0xx;..\code\components\bsp\apm32f051_barometer;..\code\components\bsp\apm32f051_barometer\Board_APM32F051_EVAL\inc;..\code\components\hal\common;..\code\components\hal\include;..\code\components\hal\target\apm32f051_barometer;..\code\components\hal\target\apm32f051_barometer\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ../code/app/barometer/: iot_app.h iot_app_osal.c iot_app_common_data.c iot_app_barometer_disp.c iot_app_data_processing_and_output_control.c iot_app_menu_item.c
  group main
    ../code/main/: main.c OnBoard.c OnBoard.h
    ../code/main/apm32f0xx/: apm32f0xx_int.c
  group osal
    ../code/components/osal/common/: OSAL.c OSAL_Memory.c OSAL_Timers.c OSAL_Clock.c OSAL_PwrMgr.c OSAL_Nv.c
    ../code/components/osal/include/: OSAL.h OSAL_Memory.h OSAL_Timers.h OSAL_Clock.h comdef.h ZComDef.h OSAL_PwrMgr.h
  group driver/lib
    ../code/components/driver/lib/apm32f0xx/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c
  group driver/usr
    ../code/components/driver/usr/apm32f0xx/: iot_driver_gpio.c iot_driver_gpio.h iot_driver_clock.c iot_driver_clock.h
  group bsp
    ../code/components/bsp/apm32f051_barometer/: board.c
    ../code/components/bsp/apm32f051_barometer/Board_APM32F051_EVAL/src/: bsp_lcd.c bsp_delay.c
  group hal/common
    ../code/components/hal/common/: hal_assert.c hal_drivers.c hal_key.c hal_timer.c hal_led.c hal_segment.c
  group hal/include
    ../code/components/hal/include/: hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_sleep.h hal_flash.h hal_key.h hal_nixietube.h hal_segment.h hal_segment_font.h hal_adc.h hal_usart.h
  group hal/target/apm32f051
    ../code/components/hal/target/apm32f051_barometer/: hal_board_cfg.h hal_mcu.h hal_types.h hal_flash.c hal_adc.c hal_usart.c
  group hal/target/apm32f051/cmsis
    ../code/components/hal/target/apm32f051_barometer/CMSIS/arm/: startup_apm32f051.s
    ../code/components/hal/target/apm32f051_barometer/CMSIS/: system_apm32f0xx.c
