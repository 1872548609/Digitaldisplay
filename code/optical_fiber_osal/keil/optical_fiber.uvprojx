# Keil uVision project optical_fiber.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: APM32F051K8 Geehy
  pack: Geehy.APM32F0xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: optical-fiber +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_APM32F051_EVAL,APM32F051 __KEIL__ ASSERT_WHILE
  c include: ..\code\app;..\code\main;..\code\components\osal\common;..\code\components\osal\include;..\code\components\osal\mcu\apm32f0xx;..\code\components\driver\lib\apm32f0xx\inc;..\code\components\bsp\apm32f051;..\code\components\bsp\apm32f051\Board_APM32F051_EVAL\inc;..\code\components\hal\common;..\code\components\hal\include;..\code\components\hal\target\apm32f051;..\code\components\hal\target\apm32f051\CMSIS;..\code\components\driver\usr\apm32f0xx
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ../code/app/: osal_app.c iot_app.c menu_app.c iot_menu.c
  group main
    ../code/main/: main.c main.h apm32f0xx_int.c OnBoard.c OnBoard.h
  group osal
    ../code/components/osal/common/: OSAL.c OSAL_Memory.c OSAL_Timers.c OSAL_Clock.c OSAL_PwrMgr.c
    ../code/components/osal/include/: OSAL.h OSAL_Memory.h OSAL_Timers.h OSAL_Clock.h comdef.h ZComDef.h OSAL_PwrMgr.h
  group driver/lib
    ../code/components/driver/lib/apm32f0xx/src/: apm32f0xx_adc.c apm32f0xx_can.c apm32f0xx_cec.c apm32f0xx_comp.c apm32f0xx_crc.c apm32f0xx_crs.c apm32f0xx_dac.c apm32f0xx_dbg.c apm32f0xx_dma.c apm32f0xx_eint.c apm32f0xx_fmc.c apm32f0xx_gpio.c apm32f0xx_i2c.c apm32f0xx_iwdt.c apm32f0xx_misc.c apm32f0xx_ob.c apm32f0xx_pmu.c apm32f0xx_rcm.c apm32f0xx_rtc.c apm32f0xx_spi.c apm32f0xx_syscfg.c apm32f0xx_tmr.c apm32f0xx_usart.c apm32f0xx_wwdt.c apm32f0xx_hal.c
  group driver/usr
    ../code/components/driver/usr/apm32f0xx/: iot_driver_gpio.c iot_driver_gpio.h iot_driver_clock.c iot_driver_flash.c iot_driver_clock.h iot_driver_div.c iot_driver_div.h iot_driver_menu.h iot_driver_font.h
  group bsp
    ../code/components/driver/usr/apm32f0xx/: iot_driver_clock.h
    ../code/components/bsp/apm32f051/: board.c
    ../code/components/bsp/apm32f051/Board_APM32F051_EVAL/src/: bsp_lcd.c bsp_delay.c
  group hal/common
    ../code/components/hal/common/: hal_assert.c hal_drivers.c
  group hal/include
    ../code/components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h hal_nixietube_display.h
  group hal/target/apm32f051
    ../code/components/hal/target/CC2530EB/: hal_types.h hal_mcu.h
    ../code/components/hal/target/apm32f051/: hal_key.c hal_led.c hal_timer.c hal_timer.h hal_nixietube_display.c
  group hal/target/apm32f051/cmsis
    ../code/components/hal/target/apm32f051/CMSIS/: system_apm32f0xx.c
    ../code/components/hal/target/apm32f051/CMSIS/arm/: startup_apm32f051.s
